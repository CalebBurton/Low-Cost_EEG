* /Users/calebburton/Documents/GitHub/Ganglion_Hardware_Design_Files/Ganglion_KiCad_Files/Ganglion_01.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Tuesday, March 06, 2018 'PMt' 03:03:28 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
XU7  VAA Net-_C10-Pad2_ V_REF V_REF Net-_C11-Pad1_ ? V_REF V_REF ? GNDA GNDA GNDA GNDA /REF+_OUT GNDA GNDA GNDA MCP_DRDY GNDA GNDA Net-_C43-Pad2_ Net-_C38-Pad2_ /MCP_SS SCK MISO MOSI /MCP_RST VDD MCP3912
XU9  /V_IN GNDA /V_ENABLE ? VDD NCP551
XU11  /V_IN GNDA /V_ENABLE ? VAA NCP551
XU10  /V_ENABLE /V_IN GNDA ? ? NCP300
SW5  /V_IN /V_BATT /V_BATT SPDT
C4  VAA GNDA 0.1uF
C2  VAA GNDA 0.1uF
C1  VAA GNDA 0.1uF
C10  GNDA Net-_C10-Pad2_ 1uF
C3  VAA GNDA 0.1uF
C11  Net-_C11-Pad1_ GNDA 1uF
C21  GNDA VDD 0.1uF
C24  GNDA VAA 0.1uF
C26  GNDA /V_IN 0.1uF
C25  GNDA /V_IN 1uF
C31  GNDA /V_IN 0.1uF
C30  GNDA /V_IN 1uF
C32  GNDA VAA 0.1uF
C33  GNDA VAA 1uF
C34  GNDA VAA 10uF
C27  GNDA VDD 0.1uF
C28  GNDA VDD 1uF
C29  GNDA VDD 10uF
XU8  GNDA GNDA ? GNDA ? GNDA VDD /SIM_RST ? ? DAC_SS SD_SS MOSI SCK MISO /D_12 /D_11 /D_9 GNDA DRDY /D_5|A_6 /D_3|A_4 /SIM_RX /D_2|A_3 /SIM_TX /MCP_SS ? ? /D_14 GNDA uA_SENS /D_4|A_5 /MCP_RST /D_23 /D_24 /D_21 Z_TEST_REF ? ? Z_TEST_2 Z_TEST_1 GNDA GNDA GNDA GNDA rfd_77101
R38  /SIM_RST VDD 10K
R37  VDD /MCP_RST 100K
C18  VDD GNDA 10uF
C19  VDD GNDA 1uF
C20  VDD GNDA 0.1uF
R2  1_IN+ I_BIAS 330K
R4  2_IN+ I_BIAS 330K
P4  VDD GNDA MISO SCK ? ? MOSI /D_12 CONN_01X08
C15  /REF+_OUT GNDA 0.1uF
C16  VAA GNDA 0.1uF
C17  VAA GNDA 1uF
C22  VDD GNDA 0.1uF
C23  VDD GNDA 1uF
P2  /D_14 /SIM_RST /D_4|A_5 /D_23 CONN_01X04
P3  /D_24 /D_21 VDD GNDA CONN_01X04
P5  ? /SIM_TX /D_2|A_3 /SIM_RX /D_3|A_4 /D_5|A_6 /D_9 /D_11 CONN_01X08
XU2  VAA 1_IN+ REF GNDA VAA REF_1 Net-_R15-Pad1_ OUT_1 AD8237
R23  Net-_C10-Pad2_ OUT_1 1K
R16  Net-_R15-Pad1_ V_REF 2K
R15  Net-_R15-Pad1_ OUT_1 100K
XU3  VAA 2_IN+ REF GNDA VAA REF_2 Net-_R17-Pad1_ OUT_2 AD8237
R17  Net-_R17-Pad1_ OUT_2 100K
R18  Net-_R17-Pad1_ V_REF 2K
R24  Net-_C11-Pad1_ OUT_2 1K
C14  Net-_C14-Pad1_ GNDA 1uF
XU6  I_BIAS I_BIAS Net-_C14-Pad1_ GNDA /REF+_OUT V_REF V_REF VAA LM7332
R27  VAA Net-_C14-Pad1_ 100K
R28  Net-_C14-Pad1_ GNDA 100K
R11  I_BIAS REF 330K
D1  /V_BATT Net-_B1-Pad1_ D_Schottky
SW6  GNDA GNDA /SIM_RST /SIM_RST TACT_SWITCH
C43  GNDA Net-_C43-Pad2_ 18pF
D2  Net-_D2-Pad1_ /D_23 LED
R47  Net-_D2-Pad1_ GNDA 1K
B1  Net-_B1-Pad1_ GNDA GNDA GNDA JS_2_Battery
C38  GNDA Net-_C38-Pad2_ 18pF
XU25  Net-_C45-Pad1_ GNDA Net-_C46-Pad1_ Net-_C46-Pad1_ VAA MCP6V31U
R32  VAA Net-_C45-Pad1_ 100K
R33  Net-_C45-Pad1_ GNDA 100K
C45  Net-_C45-Pad1_ GNDA 1uF
P1  GNDA ? D_G ? REF ? ? ? ? ? 2_IN+ ? 1_IN+ ? VAA ? CONN_02X08
Y1  Net-_C38-Pad2_ Net-_C43-Pad2_ 3.2768 MHz
R49  Net-_C46-Pad1_ D_G 330K
C46  Net-_C46-Pad1_ D_G 1uF
* Sheet Name: /SENSORS/
XU12  DAC_SS SCK MOSI VDD GNDA Net-_R39-Pad1_ AD5621
XU15  Net-_R42-Pad1_ GNDA Net-_C40-Pad1_ Net-_R42-Pad1_ VDD MCP6001
XU14  uA_SENS GNDA Net-_R40-Pad1_ Net-_R41-Pad1_ VDD MCP6V13T
R39  Net-_R39-Pad1_ /SENSORS/IMP_SIG 100
R40  Net-_R40-Pad1_ Net-_R39-Pad1_ 1K
R41  Net-_R41-Pad1_ /SENSORS/IMP_SIG 1K
R42  Net-_R42-Pad1_ Net-_R40-Pad1_ 1M
R43  uA_SENS Net-_R41-Pad1_ 1M
R44  VDD Net-_C40-Pad1_ 100K
R45  Net-_C40-Pad1_ GNDA 100K
C40  Net-_C40-Pad1_ GNDA 1uF
XU13  ? SD_SS MOSI VDD SCK GNDA MISO ? ? GNDA GNDA GNDA GNDA SEEED_microSD
C35  GNDA VDD 100uF
XU21  /SENSORS/IMP_SIG 1_IN+ GNDA Z_TEST_1 VDD 74LVC1G66
XU18  /SENSORS/IMP_SIG 2_IN+ GNDA Z_TEST_2 VDD 74LVC1G66
XU22  /SENSORS/IMP_SIG REF GNDA Z_TEST_REF VDD 74LVC1G66
XU23  MCP_DRDY DRDY DRDY GNDA Net-_C36-Pad2_ Net-_C36-Pad2_ Net-_C36-Pad1_ VDD 74LVC2G00
C36  Net-_C36-Pad1_ Net-_C36-Pad2_ 0.01uF
R46  Net-_C36-Pad2_ GNDA 100K
* Sheet Name: /INPUT_V_REF/
C9  Net-_C9-Pad1_ REF_1 22uF
R1  Net-_C9-Pad1_ REF_1 1M
R12  OUT_1 Net-_C9-Pad1_ 1M
C39  Net-_C39-Pad1_ REF_2 22uF
R14  Net-_C39-Pad1_ REF_2 1M
R30  OUT_2 Net-_C39-Pad1_ 1M
XU1  Net-_R34-Pad2_ GNDA Net-_C9-Pad1_ REF_1 VAA MCP6V31U
R34  V_REF Net-_R34-Pad2_ 500K
R36  V_REF Net-_R36-Pad2_ 500K
XU26  Net-_R36-Pad2_ GNDA Net-_C39-Pad1_ REF_2 VAA MCP6V31U
* Sheet Name: /INPUT_PROTECTION/
XU28  D_G GNDA GNDA ? REF ? TPD4E1B06
XU29  ? 2_IN+ GNDA VAA 1_IN+ ? TPD4E1B06

.end
